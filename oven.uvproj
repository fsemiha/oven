# Keil uVision project oven.uvproj, settings and files
target Target1 (MCS-51)
  device: ML56LD1AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0xFFFF)  XRAM(0 - 0xFFF) CLOCK(24000000)
  output: Project +hex
  c flags: Optimize=9 SizeSpeed=1
  c include: ..\Library\Device\Include;..\Library\StdDriver\inc
  group Source Group 1
    ../: main.c
  group Library
    C:/Users/unal/OneDrive - Fatih Sultan Mehmet Vakıf Üniversitesi/Masaüstü/FatmaSemihaUnal/Delsa/YEDEK_oven/10.05.2023_17.45/Library/StdDriver/src/: sys.c common.c
  group Startup
    C:/Users/unal/OneDrive - Fatih Sultan Mehmet Vakıf Üniversitesi/Masaüstü/FatmaSemihaUnal/Delsa/YEDEK_oven/10.05.2023_17.45/Library/Startup/KEIL/: STARTUP.A51
  group Sources
    ./: timer.c gpio_pin.c global.c events.c pwm_buzzer.c icon.c
  group Headers
    ./: timer.h gpio_pin.h global.h events.h pwm_buzzer.h icon.h
